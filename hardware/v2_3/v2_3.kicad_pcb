# Repository pondahai/makecode_arcade_console

File README.md:

# makecode_arcade_console

V3.1

## KiCad design hardware/v2_3/v2_3.kicad_pcb

Parts:
BT1: Dry Batt; BatteryHolder_Keystone_2479_3xAAA
BT2: Li-Poly; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C2, C7, C8, C10, C11, C12, C13, C14, C16: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C15, C17, C18, C19, C20, C21, C22: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C9: 2u2; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: 1N4148W; D_SOD-123
D2: MBR0540; D_SOD-123
D3: GP25; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: charge; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: LCM; PinHeader_1x08_P2.54mm_Vertical
J2: GPIO; PinHeader_1x16_P2.54mm_Horizontal
J3: STP0177A-128160; JST_SUR_SM14B-SURS-TF_1x14-1MP_P0.80mm_Horizontal
J4: Micro_SD_Card; sd-card
J5: SWD; PinHeader_1x03_P2.54mm_Vertical
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J7: AudioJack3; audiojack-3.5mm-5p
J8: psp_thumbstick; psp_thumb_joystick
J9: STP0280A1; STP0280A1-240320
Q1, Q2: DMG2305UX; SOT-23_Handsoldering
Q3, Q4: 2N7002; SOT-23
Q5: MMBT3904; SOT-23
R1, R3, R4, R11, R12, R13, R16, R17, R24, R26, R27, R28, R29: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R14, R22, R25: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R15: 5k1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10: 27; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R21, R30, R31: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R20: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23: 33k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN1, RN2: 47k; R_Array_Convex_4x0603
RN3: 10; R_Array_Convex_4x0603
SW1: POWER; MK12C02
SW2: UP P9; Silent SMD TACT Push Button Switch
SW3: LEFT P8; Silent SMD TACT Push Button Switch
SW4: RIGHT P6; Silent SMD TACT Push Button Switch
SW5: DOWN P5; Silent SMD TACT Push Button Switch
SW6: B P3; Silent SMD TACT Push Button Switch
SW7: A P2; Silent SMD TACT Push Button Switch
SW8: MENU P4; Silent SMD TACT Push Button Switch
SW9: RUN; skrp
SW10: BOOT; skrp
SW11: ALT P28; Silent SMD TACT Push Button Switch
SW12: POWER; SW_CuK_OS102011MA1QN1_SPDT_Angled
SW13: POWER; SW_CuK_JS202011AQN_DPDT_Angled
TP1: sound_analog; TestPoint_Pad_D1.5mm
TP2: snd_analog_buffered; TestPoint_Pad_D1.5mm
TP3: VBUS; TestPoint_Pad_D1.5mm
TP4: VSYS; TestPoint_Pad_D1.5mm
TP5: GND; TestPoint_Pad_D1.5mm
TP6: VBAT; TestPoint_Pad_D1.5mm
TP7: D; TestPoint_Pad_D1.5mm
TP8: S; TestPoint_Pad_D1.5mm
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2, U7: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U3: MCP6002-xSN; SOIC-8_3.9x4.9mm_P1.27mm
U4: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U5: AP2112K-3.3; SOT-23-5
U6: MCP73831-2-OT; SOT-23-5
Y1: 12MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C2.1, C3.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, J1.2, J2.1, J3.4, J3.10, J3.11, J4.4 (VDD), J8.3, J8.4, J9.9, J9.10, Q2.2 (S), R1.2, R3.2, R11.2, R17.2, R18.2, R19.2, R24.1, R27.2, R28.2, R29.2, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.8 (V+), U3.8 (V+), U4.8 (VCC), U5.5 (VOUT), U7.8 (V+)
/ADC0_P26: J2.9, J8.2, U1.38 (GPIO26_ADC0), U7.2 (-), U7.5 (+)
/ADC1_P27: J2.11, J8.5, U1.39 (GPIO27_ADC1), U2.3 (+), U2.6 (-)
/BL_P22: J1.8, J2.10, R25.2, U1.34 (GPIO22)
/BOOT: C21.2, Q4.3 (D), R6.2, R24.2, SW10.4 (A)
/BTN_ALT_P28: J2.14, SW11.1, U1.40 (GPIO28_ADC2)
/BTN_A_P2: SW7.1, U1.4 (GPIO2)
/BTN_B_P3: SW6.1, U1.5 (GPIO3)
/BTN_DOWN_P5: R27.1, SW5.1, U1.7 (GPIO5), U2.1
/BTN_LEFT_P8: R29.1, SW3.1, U1.11 (GPIO8), U7.7
/BTN_MENU_P4: SW8.1, U1.6 (GPIO4)
/BTN_RIGHT_P6: R28.1, SW4.1, U1.8 (GPIO6), U7.1
/BTN_UP_P9: R1.1, SW2.1, U1.12 (GPIO9), U2.7
/BZ_Disable: J2.15, R3.1, R4.1, U3.2 (-)
/CS_P17: J1.7, J2.6, J3.12, J9.5, U1.28 (GPIO17)
/D+: R10.1, U1.47 (USB_DP)
/D-: R9.1, U1.46 (USB_DM)
/DC_P20: J1.6, J2.5, J3.7, J9.4, U1.31 (GPIO20)
/EN: R13.1, SW1.2 (B), SW12.2 (B), SW13.2 (B), U5.3 (EN)
/LED-: J3.3, J9.14, RN3.4 (R4.1)
/MISO_P16: J2.2, U1.27 (GPIO16)
/MOSI_P19: J1.4, J3.8, J9.6, U1.30 (GPIO19)
/P0: J2.13, U1.2 (GPIO0)
/P1: J2.12, U1.3 (GPIO1)
/P14: J2.8, U1.17 (GPIO14)
/P15: J2.7, U1.18 (GPIO15)
/P25: R14.1, U1.37 (GPIO25)
/QSPI_CS: R6.1, R11.1, U1.56 (QSPI_SS), U4.1 (~CS)
/QSPI_SCLK: U1.52 (QSPI_SCLK), U4.6 (CLK)
/QSPI_SD0: U1.53 (QSPI_SD0), U4.5 (DI(IO0))
/QSPI_SD1: U1.55 (QSPI_SD1), U4.2 (DO(IO1))
/QSPI_SD2: U1.54 (QSPI_SD2), U4.3 (IO2)
/QSPI_SD3: U1.51 (QSPI_SD3), U4.7 (IO3)
/RST_P21: J1.5, J2.4, J3.6, J9.2, U1.32 (GPIO21)
/RUN: Q2.1 (G), R17.1, SW9.2, U1.26 (RUN)
/SCK_P18: J1.3, J3.9, J9.3, U1.29 (GPIO18)
/SD_CS_P13: J4.2 (DAT3/CD), RN1.2 (R2.1), U1.16 (GPIO13)
/SD_DAT1: J4.8 (DAT1), RN2.2 (R2.1)
/SD_DAT2: J4.1 (DAT2), RN1.1 (R1.1)
/SD_MISO_P12: J4.7 (DAT0), RN2.1 (R1.1), U1.15 (GPIO12)
/SD_MOSI_P11: J4.3 (CMD), RN1.3 (R3.1), U1.14 (GPIO11)
/SD_SCK_P10: J4.5 (CLK), RN1.4 (R4.1), U1.13 (GPIO10)
/SND_P7: R2.1, U1.9 (GPIO7)
/SWCLK: J5.3, U1.24 (SWCLK)
/SWD: J5.1, U1.25 (SWD)
/V1_1: C6.1, C7.1, C8.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
/VBAT: BT1.1, BT2.1, Q1.3 (D), TP6.1, TP7.1, U6.3 (VBAT)
/VBUS: D2.2 (A), D4.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), Q1.1 (G), R12.2, TP3.1, U6.4 (VDD)
/VSYS: C15.1, D2.1 (K), Q1.2 (S), R13.2, TP4.1, TP8.1, U5.1 (VIN)
/sound: C22.2, J2.16, J7.T, R30.2
GNDREF: BT1.2, BT2.2, BZ1.2 (+), C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.2 (A), D3.1 (K), J1.1, J2.3, J3.2, J3.5, J3.13, J4.6 (VSS), J5.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), J7.S, J8.1, J8.6, J9.1, J9.8, Q3.2 (S), Q4.2 (S), Q5.2 (E), R4.2, R7.1, R8.1, R12.1, R15.2, R20.1, R21.1, R22.1, R23.1, R26.1, R30.1, R31.1, SW1.1 (A), SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.3 (K), SW10.2, SW11.2, SW12.1 (A), SW13.1 (A), TP5.1, U1.19 (TESTEN), U1.57 (GND), U2.4 (V-), U3.4 (V-), U4.4 (GND), U5.2 (GND), U6.2 (VSS), U7.4 (V-), Y1.2, Y1.4
unnamed: BZ1.1 (-), D1.1 (K), R31.2, U3.1
unnamed: C1.1, J7.RN, R2.2, TP1.1, U3.5 (+)
unnamed: C4.2, U1.20 (XIN), Y1.1
unnamed: C5.2, R5.1, Y1.3
unnamed: C19.2, Q3.1 (G), R22.2
unnamed: C20.2, Q2.3 (D), Q3.3 (D), Q4.1 (G), R23.2
unnamed: C22.1, TP2.1, U3.6 (-), U3.7
unnamed: D3.2 (A), R14.2
unnamed: D4.1 (K), R16.1
unnamed: J6.A5 (CC1), R7.2
unnamed: J6.A6 (D+), J6.B6 (D+), R10.2
unnamed: J6.A7 (D-), J6.B7 (D-), R9.2
unnamed: J6.B5 (CC2), R8.2
unnamed: J7.R, U3.3 (+)
unnamed: J9.11, RN3.1 (R1.1)
unnamed: J9.12, RN3.2 (R2.1)
unnamed: J9.13, RN3.3 (R3.1)
unnamed: Q5.1 (B), R25.1, R26.2
unnamed: Q5.3 (C), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2)
unnamed: R5.2, U1.21 (XOUT)
unnamed: R15.1, U6.5 (PROG)
unnamed: R16.2, U6.1 (STAT)
unnamed: R18.1, R20.2, U2.5 (+), U7.3 (+)
unnamed: R19.1, R21.2, U2.2 (-), U7.6 (-)

Notes on the sheet:
1 NC 2 GND 3 LED- 4 LED+ 5 GND 6 RESET 7 A0 8 SDA 9 SCK 10 VCC 11 IOVCC 12 CS 13 GND 14 NC
1.03V
1 GND 2 VDD 3 SCL 4 SDA 5 RST 6 DC 7 CS 8 BLK
USB
MCU
顯示器
類比 搖桿
ON -- | --OFF
16MB FLASH
PIN_BTN_A = P_2 PIN_BTN_B = P_3 PIN_BTN_MENU = P_4 PIN_BTN_DOWN = P_5 PIN_BTN_RIGHT = P_6 PIN_BTN_LEFT = P_8 PIN_BTN_UP = P_9 PIN_DISPLAY_BL = P_22 PIN_DISPLAY_CS = P_17 PIN_DISPLAY_DC = P_20 PIN_DISPLAY_MISO = P_16 PIN_DISPLAY_MOSI = P_19 PIN_DISPLAY_RST = P_21 PIN_DISPLAY_SCK = P_18 PIN_JACK_SND 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
2.26V
one-shot boot

Board: 2 copper layers, 76.0 x 90.0 mm, 106 parts (93 on the bottom side), 75 nets.

## KiCad design hardware/v1_2/mca_game_console.kicad_pcb

Parts:
BT1: Dry; BatteryHolder_Keystone_2479_3xAAA
BT2: Li-Poly; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C2: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: 1N4148W; D_SOD-123
J1: LCD; PinHeader_1x08_P2.54mm_Vertical
J2: GPIO; PinHeader_1x16_P2.54mm_Horizontal
J3: LCM; JST_SUR_SM14B-SURS-TF_1x14-1MP_P0.80mm_Horizontal
J4: Micro_SD_Card; sd-card
J5: SWD; PinHeader_1x03_P2.54mm_Vertical
Q1: DMG2305UX; SOT-23_Handsoldering
R1: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 330; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN1, RN2: 47k; R_Array_Convex_4x0603
SW1: SW_SPDT; MK12C02
SW2: UP P9; Silent SMD TACT Push Button Switch
SW3: LEFT P8; Silent SMD TACT Push Button Switch
SW4: RIGHT P6; Silent SMD TACT Push Button Switch
SW5: DOWN P5; Silent SMD TACT Push Button Switch
SW6: B P3; Silent SMD TACT Push Button Switch
SW7: A P2; Silent SMD TACT Push Button Switch
SW8: MENU P4; Silent SMD TACT Push Button Switch
SW9: RUN; skrp
SW10: UP; PB-002
SW11: LEFT; PB-002
SW12: RIGHT; PB-002
SW13: DOWN; PB-002
SW14: B; PB-002
SW15: A; PB-002
SW16: MENU; PB-002
SW17: UP; SW_PUSH-12mm
SW18: LEFT; SW_PUSH-12mm
SW19: RIGHT; SW_PUSH-12mm
SW20: DOWN; SW_PUSH-12mm
SW21: B; SW_PUSH-12mm
SW22: A; SW_PUSH-12mm
SW23: MENU; SW_PUSH-12mm
SW24: SW_SPDT; SW_CuK_OS102011MA1QN1_SPDT_Angled
TP1: sound_analog; TestPoint_Pad_D1.5mm
TP2: sound_analog_buffered; TestPoint_Pad_D1.5mm
TP3: VBUS; TestPoint_Pad_D1.5mm
TP4: VSYS; TestPoint_Pad_D1.5mm
TP5: GND; TestPoint_Pad_D1.5mm
TP6: VBAT; TestPoint_Pad_D1.5mm
TP7: D; TestPoint_Pad_D1.5mm
TP8: S; TestPoint_Pad_D1.5mm
U1: WeAct-RP2040-Pico; RPi_Pico_SMD_TH
U2: MCP6002-xP; DIP-8_W7.62mm_LongPads
U3: MCP6002-xSN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, J1.2, J2.1, J3.10, J3.11, J4.4 (VDD), R1.1, R3.2, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), U1.36 (3V3), U2.8 (V+), U3.8 (V+)
/BL_P22: J1.8, J2.13, U1.29 (GPIO22)
/BTN_A_P2: SW7.1, SW15.1, SW22.1, U1.4 (GPIO2)
/BTN_B_P3: SW6.1, SW14.1, SW21.1, U1.5 (GPIO3)
/BTN_DOWN_P5: SW5.1, SW13.2, SW20.1, U1.7 (GPIO5)
/BTN_LEFT_P8: SW3.1, SW11.2, SW18.1, U1.11 (GPIO8)
/BTN_MENU_P4: SW8.1, SW16.1, SW23.1, U1.6 (GPIO4)
/BTN_RIGHT_P6: SW4.1, SW12.1, SW19.1, U1.9 (GPIO6)
/BTN_UP_P9: SW2.1, SW10.1, SW17.1, U1.12 (GPIO9)
/BZ_Disable: J2.15, R3.1, R4.1, U2.2 (-), U3.2 (-)
/CS_P17: J1.7, J2.12, J3.12, U1.22 (GPIO17)
/DC_P20: J1.6, J2.10, J3.7, U1.26 (GPIO20)
/MISO_P16: J2.5, U1.21 (GPIO16)
/MOSI_P19: J1.4, J3.8, U1.25 (GPIO19)
/P0: J2.16, U1.1 (GPIO0)
/P1: J2.14, U1.2 (GPIO1)
/P14: J2.4, U1.19 (GPIO14)
/P15: J2.2, U1.20 (GPIO15)
/P26: J2.7, U1.31 (GPIO26_ADC0)
/P27: J2.9, U1.32 (GPIO27_ADC1)
/P28: J2.11, U1.34 (GPIO28_ADC2)
/RST_P21: J1.5, J2.8, J3.6, U1.27 (GPIO21)
/RUN: SW9.2, U1.30 (RUN)
/SCK_P18: J1.3, J3.9, U1.24 (GPIO18)
/SD_CS_P13: J4.2 (DAT3/CD), RN1.2 (R2.1), U1.17 (GPIO13)
/SD_DAT1: J4.8 (DAT1), RN1.3 (R3.1)
/SD_DAT2: J4.1 (DAT2), RN2.2 (R2.1)
/SD_MISO_P12: J4.7 (DAT0), RN1.1 (R1.1), U1.16 (GPIO12)
/SD_MOSI_P11: J4.3 (CMD), RN2.4 (R4.1), U1.15 (GPIO11)
/SD_SCK_P10: J4.5 (CLK), RN2.3 (R3.1), U1.14 (GPIO10)
/SND_P7: R2.1, U1.10 (GPIO7)
/sound: J2.6, TP2.1, U2.6 (-), U2.7, U3.6 (-), U3.7
GNDREF: BT1.2 (-), BT2.2 (-), BZ1.2 (+), C1.2, C2.2, C3.2, D1.2 (A), J1.1, J2.3, J3.2, J3.3, J3.5, J3.13, J4.6 (VSS), J5.2, R4.2, SW1.1 (A), SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.3 (K), SW10.2, SW11.1, SW12.2, SW13.1, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, SW21.2, SW22.2, SW23.2, SW24.1 (A), TP5.1, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND), U2.4 (V-), U3.4 (V-)
unnamed: BT1.1 (+), BT2.1 (+), Q1.3 (D), TP6.1, TP8.1
unnamed: BZ1.1 (-), D1.1 (K), U2.1, U3.1
unnamed: C1.1, R2.2, TP1.1, U2.3 (+), U2.5 (+), U3.3 (+), U3.5 (+)
unnamed: J3.4, R1.2
unnamed: Q1.1 (G), TP3.1, U1.40 (VBUS)
unnamed: Q1.2 (S), TP4.1, TP7.1, U1.39 (VSYS)
unnamed: SW1.2 (B), SW24.2 (B), U1.37 (3V3_EN)
unnamed: J5.3, U1.41 (SWCLK)
unnamed: J5.1, U1.43 (SWDIO)

Notes on the sheet:
1 NC 2 GND 3 LED- 4 LED+ 5 GND 6 RESET 7 A0 8 SDA 9 SCK 10 VCC 11 IOVCC 12 CS 13 GND 14 NC
1 GND 2 VDD 3 SCL 4 SDA 5 RST 6 DC 7 CS 8 BLK
3V3 OUTPUT ONLY
PIN_BTN_A = P_2 PIN_BTN_B = P_3 PIN_BTN_MENU = P_4 PIN_BTN_DOWN = P_5 PIN_BTN_RIGHT = P_6 PIN_BTN_LEFT = P_8 PIN_BTN_UP = P_9 PIN_DISPLAY_BL = P_22 PIN_DISPLAY_CS = P_17 PIN_DISPLAY_DC = P_20 PIN_DISPLAY_MISO = P_16 PIN_DISPLAY_MOSI = P_19 PIN_DISPLAY_RST = P_21 PIN_DISPLAY_SCK = P_18 PIN_JACK_SND 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

Board: 2 copper layers, 66.0 x 99.8 mm, 54 parts (24 on the bottom side), 42 nets.

File hardware/v2_3/bom.xlsx:

null | Sourced | Placed | References | Value | Footprint | Quantity
1 |  |  | C1 | 100n | C_0805_2012Metric_Pad1.18x1.45mm_HandSolder | 1
2 |  |  | R3, R4 | 10k | R_0805_2012Metric_Pad1.20x1.40mm_HandSolder | 2
3 |  |  | R1 | R_US | R_0805_2012Metric_Pad1.20x1.40mm_HandSolder | 1
4 |  |  | R2 | 330 | R_0805_2012Metric_Pad1.20x1.40mm_HandSolder | 1
5 |  |  | D1 | 1N4148W | D_SOD-123 | 1
6 |  |  | U1 | WeAct-RP2040-Pico | RPi_Pico_SMD_TH | 1 | 143
7 |  |  | U2 | MCP6002-xP | DIP-8_W7.62mm_LongPads | 1 | 15.08
8 |  |  | SW1 | SW_SPDT | MK12C02 | 1 | 2
9 |  |  | SW2 | UP | Silent SMD TACT Push Button Switch | 1
10 |  |  | SW3 | LEFT | Silent SMD TACT Push Button Switch | 1
11 |  |  | SW4 | RIGHT | Silent SMD TACT Push Button Switch | 1
12 |  |  | SW5 | DOWN | Silent SMD TACT Push Button Switch | 1
13 |  |  | SW6 | B | Silent SMD TACT Push Button Switch | 1
14 |  |  | SW7 | A | Silent SMD TACT Push Button Switch | 1
15 |  |  | SW8 | MENU | Silent SMD TACT Push Button Switch | 1
16 |  |  | SW9 | RUN | skrp | 1 | 2.3199999999999998
17 |  |  | SW10 | UP | PB-002 | 1 | 5 | 11.3
18 |  |  | SW11 | LEFT | PB-002 | 1 | 5 | 11.3
19 |  |  | SW12 | RIGHT | PB-002 | 1 | 5 | 11.3
20 |  |  | SW13 | DOWN | PB-002 | 1 | 5 | 11.3
21 |  |  | SW14 | B | PB-002 | 1 | 5 | 11.3
22 |  |  | SW15 | A | PB-002 | 1 | 5 | 11.3
23 |  |  | SW16 | MENU | PB-002 | 1 | 5 | 11.3
24 |  |  | BT1 | Dry | BatteryHolder_Keystone_2479_3xAAA | 1 | 11.3
25 |  |  | BT2 | Li-Poly | JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical | 1
26 |  |  | BZ1 | Buzzer | Buzzer_15x7.5RM7.6 | 1 | 7.69
27 |  |  | Q1 | DMG1012T | SOT-523 | 1
28 |  |  | TP1 | sound_analog | TestPoint_Pad_D1.5mm | 1
29 |  |  | TP2 | sound_analog_buffered | TestPoint_Pad_D1.5mm | 1
30 |  |  | TP3 | VBUS | TestPoint_Pad_D1.5mm | 1
31 |  |  | TP4 | VSYS | TestPoint_Pad_D1.5mm | 1
32 |  |  | TP5 | GND | TestPoint_Pad_D1.5mm | 1
33 |  |  | TP6 | VBAT | TestPoint_Pad_D1.5mm | 1
34 |  |  | TP7 | D | TestPoint_Pad_D1.5mm | 1
35 |  |  | TP8 | S | TestPoint_Pad_D1.5mm | 1
36 |  |  | J1 | Conn_01x08 | PinHeader_1x08_P2.54mm_Vertical | 1
37 |  |  | J2 | GPIO | PinHeader_1x16_P2.54mm_Horizontal | 1
38 |  |  | J3 | Conn_01x14 | JST_SUR_SM14B-SURS-TF_1x14-1MP_P0.80mm_Horizontal | 1 | 78.8
 |  |  |  | PCB | JLCPCB | 1 | 29.5
